# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\lsens;.\Font;.\Fatfs\src;.\Fatfs\fatfs_app;.\Fatfs\src\option;.\APP\ws2812;.\APP\spi;.\APP\flash;.\APP\sd_sdio;.\Malloc;.\APP\adc;.\APP\adc_temp;.\APP\esp8266;.\APP\esp8266_mqtt;.\APP\beep;.\APP\pwm2;.\APP\hwjs;.\APP\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_sdio.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/dht11/: dht11.c dht11_2.c
    ./APP/pwm/: pwm.c
    ./APP/lsens/: lsens.c
    ./APP/ws2812/: ws2812.c
    ./APP/sd_sdio/: sd_sdio.c
    ./APP/flash/: flash.c
    ./APP/spi/: spi.c
    ./APP/adc/: adc.c
    ./APP/adc_temp/: adc_temp.c
    ./APP/esp8266_mqtt/: esp8266_mqtt.c
    ./APP/esp8266/: esp8266.c
    ./APP/beep/: beep.c
    ./APP/hwjs/: hwjs.c
    ./APP/cJSON/: cJSON.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Font
    ./Font/: font_show.c font_update.c
  group Fatfs
    ./Fatfs/src/: diskio.c ff.c
    ./Fatfs/fatfs_app/: mycc936.c fatfs_app.c
  group Malloc
    ./Malloc/: malloc.c
